Commit message: anno modle update

File: anno010_robotic_arm/urdf/anno_chassis.urdf (robot description, URDF)
Before this commit: robot anno_chassis, 7 links, 6 joints
Links:
- link tool: geometry visual cylinder length=20 radius=2
